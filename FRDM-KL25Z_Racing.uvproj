# Keil uVision project FRDM-KL25Z_Racing.uvproj, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: FRDM-KL25Z_Racing
  AfterMake: fromelf --bin -o build\FRDM-KL25Z_Racing_KL25Z.bin build\FRDM-KL25Z_Racing.axf
  c flags: Optim=4
  c define: TARGET_KL25Z,  TARGET_M0P,  TARGET_CORTEX_M,  TARGET_Freescale,  TARGET_KLXX,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1428938202.33,  __MBED__=1,  TARGET_FF_ARDUINO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;  Spices;  FRDM-TFC
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp common.cpp
    Spices/: Spices.cpp
    FRDM-TFC/: TFC.cpp
